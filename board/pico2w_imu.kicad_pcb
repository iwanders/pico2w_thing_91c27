# Repository iwanders/pico2w_thing_91c27

File README.md:

# Pico2w_thingy_91c27

A project for a PCB with a bunch of sensors on it that attaches to a Raspberry Pi Pico 2W to log things.

- ICM-42688 IMU
- LSM6DSV320X IMU
- ICS-43434 Microphone
- BME280 Humidity, Temperature, Pressure sensor.
- MX25L25645GM2I 256 megabit flash.
- MCP73833 LiPo Battery charger

See the [./board/](./board/) or the [./firmware/](./firmware/) readme's for more information.

This project led to [micro_hap](https://github.com/iwanders/micro_hap), a no_alloc, no_std implementation of Apple's
HomeKit accessory protocol. Currently the firmware makes a HomeKit temperature & humidity sensor.

Code is always `1, 1, 1, 2, 2, 3, 3, 3`, factory reset is done by powering it off during the long duration blue led for
three consecutive times. Factory reset wipes the persistent data (device address, ed_ltsk, setup info) and any pairings.

## What's with the name?
Naming is hard... This is a bit of a vague project to attempt... also:
```
$ head -c 100 /dev/urandom  | md5sum | head -c 5
91c27
```

## micro_hap

A large portion of this repository's history is around the HomeKit Accessory Protocol implementation.
This is now split out as the [micro_hap](https://github.com/iwanders/micro_hap) repository.

# License
License is [`BSD-3-Clause`](./LICENSE) for the board & firmware.

## KiCad design board/pico2w_imu.kicad_pcb

File board/README.md (part):

# Board

Notes for myself mostly.

## Connections & Information

Table of relevant connections & information.

| Device| Pin(#) | Rpi Pin | Rpi GPIO/Fun | Comment |
| --- |--- | --- | --- | --- |
| Led Indicator | 31 | GPIO26/ADC0 | | Blue, center of board |
| | | | |
| ICM-42688 |AP_SDO (1) | 6 | GPIO4/SPI0_RX  | SPI Serial data output|
| ICM-42688 |INT1 (4) | 9 | GPIO6  | Interrupt 1|
| ICM-42688 |INT2 (9) | 2 | GPIO1 | Interrupt 2, push/pull or open drain|
| ICM-42688 |AP_CS (12) | 7 | GPIO6/SPIO0_CSn | SPI Chip Select|
| ICM-42688 |AP_SCL (13) | 4 | GPIO2/SPI0_SCK | SPI Serial Clock|
| ICM-42688 |AP_SDI (14) | 5 | GPIO3/SPI0_TX | Spi Serial data Input|
| | | | |
| LSM6DSV320X | SDO (1) | 16 | GPIO12/SPI1_RX  | SPI Serial data output|
| LSM6DSV320X | INT1 (4) | 19 | GPIO14 | Programmable Interrupt |
| LSM6DSV320X | INT2 (9) | 20 | GPIO15 | Programmable Interrupt |
| LSM6DSV320X | CS (12) | 17 | GPIO13 | SPI Chip select |
| LSM6DSV320X | SCL (13) | 14 | GPIO10/SPI1_SCK | SPI Serial clock |
| LSM6DSV320X | SDA (14) | 15 | GPIO11/SPI1_TX | SPI Serial Data Input |
| | | | |
| ICS-43434 | WS (1) | 10 | GPIO7  | Serial Data-Word Select I2S |
| ICS-43434 | LR (2) |  | | Channel select solder jumper GND |
| ICS-43434 | SCK (4) | 11 | GPIO8 | Serial Data Clock I2S |
| ICS-43434 | SD (6) | 12 | GPIO9 | Serial Data Output I2S |
| | | | |
| BME280 | SDI(3) | 26  | GPIO20 /I2C0_SDA  | I2C SDA, 4.7k pullup |
| BME280 | SCK(4) | 27  | GPIO21/I2C0_SCL   | I2C SCL, 4.7k pullup |
| | | | |
| MX25L25645GM2I | CS (1) | 22  | GPIO17 / SPI0_CSn| Chip Select |
| MX25L25645GM2I | SO (2) | 21   | GPIO16 / SPI0_RX | Serial Data Output |
| MX25L25645GM2I | SCLK (6) | 24 | GPIO18/SPI0_SCK | Clock Input |
| MX25L25645GM2I | SI (5) |  25  | GPIO19/SPI0_TX  | Serial Data Input |
| | | | |
| SDCARD | CD (2) | 32  | GPIO27 / ADC1 | Chip Select |
| SDCARD | CMD (3) | 25  | GPIO19/SPI0_TX  | Serial Data Input |
| SDCARD | CLK (5) | 24 | GPIO18/SPI0_SCK | Clock Input |
| SDCARD | DAT0 (7) | 21   | GPIO16 / SPI0_RX | Serial Data Output |
| SDCARD | DET_A (10) | 29   | GPIO22  | Connects to GND with card (use internal pullup) |
| | | | |
| MCP73833| STAT1 (3) | | | Charging, Orange |
| MCP73833| STAT2 (4) | | | End of Charge, Red |
| MCP73833| PG (7) | | | Power Good, Green |
| MCP73833| PROG (6) | | | Charge current, 2.5k with two parallel 5k, 400mA default, 200mA if trace cut|
| | | | |

## Dimension notes

Pin 1 is at the origin, such that we can conveniently use a 2.54mm grid. Note to self; nothing ended up aligned on a 2.54 grid.

Vertical Center is thus at `17.78 / 2 = 8.89mm`.

Top of board is at `-(51-48.26)/2 = -1.37mm`.

Left edge of board is at `-(21-17.78) / 2 = -1.61mm`

Right edge of board is at `21 - 1.61 = 19.39mm`

Bottom edge of board is at `51 - 1.37 = 49.63mm`

Top left mounting hole is at x: `8.89 - 11.4 / 2 = 3.19`, y: `2 - 1.37=0.63mm`

Top right mounting hole is at x: `8.89 + 11.4 / 2 = 14.59`, y: `2 - 1.37=0.63mm`

Bottom mounting holes at y: `51 - 2 - 1.37`

Hole clearance: `(3.8 - 2.1) / 2 = 0.85mm`.

Debug headers are NOT at full 2.54mm offset.

Y value is 1.6mm off the botom edge; `49.63 - 1.6=48.03mm`

For the 2w; debug gnd at x: `19.39-7.3759=12.0141mm`, y at `49.63-19.8= 29.83mm`.

Swdio thus atx: `12.0141 + 2.54=14.5541mm`, swclk at `12.0141-2.54 = 9.4741mm`.

## Pico 2W
- 2648-SC1633CT-ND
- https://www.digikey.ca/en/products/detail/raspberry-pi/SC1633/25862726

## Battery Charger

Chip is `MCP73833`. Only the part ending in 33 has the power good pin, 34 is the timer flavour, which we don't want.

Is a DFN package... It has various flavours, digikey only carries VReg of 4.20v, going with no timer such that we can charge large batteries if necessary, with preconditioning, but no timer (in case we want to charge a large battery): `MCP73833-AMI/MF` in full.

- `MCP73833T-AMI/MFCT-ND`
- https://www.digikey.ca/en/products/detail/microchip-technology/MCP73833T-AMI-MF/1223181

Likely going to use a small LiPo battery, 180 mAh; like 30mm by 12mm, charge at 1C, gives about 200 mA charge current.

Equation 5-1, p17 of datasheet;

```math
I_\text{reg} = \frac{1000V}{R_\text{prog}}
```
With $I_\text{reg}$ in mA and $R_\text{prog}$ in kOhm.

To get 200mA current, we need $R_\text{prog}$ to be 5k Ohm.

To get 400mA current, we need $R_\text{prog}$ to be 2.5k Ohm.

Modified this to be two resistors of 5k, with one trace that's easily cut to drop from 400mA to 200mA.

> When the voltage at the VBAT pin reaches the regulation voltage, VREG, constant voltage regulation begins. The regulation voltage is factory set to 4.20V, 4.35V, 4.40V, or 4.50V with a tolerance of ± 0.75%.

> If temperature monitoring is not required, place a standard 10 kΩ resistor from THERM to VSS.

Capacitor C8, decoupling on vbat:
- Switched it to 0603, because there's plenty of space there (and more available)
- `1276-1044-1-ND`
- https://www.digikey.ca/en/products/detail/samsung-electro-mechanics/CL10A475KP8NNNC/3886702

Verified pin inputs.

### LEDs

Lets go with [OSRAM SMARTLED® 0603](https://ams-osram.com/products/product-families/smartled-0603) series, they seem made for diffuse indicator lights. Effectively `Kx EELP41.xx` with x changing depending on the color. Digikey [filter link](https://www.digikey.ca/en/products/filter/led-indication-discrete/105?s=N4IgjCBcoLQCxVAYygMwIYBsDOBTANCAPZQDaIAbAExwDMtIAugL7OFVkgCiXAMgApNmQA); search on series and `EELP`.

This [application note](https://look.ams-osram.com/m/7936f76d4c70ced0/original/Determination-of-resistances-for-brightness-compensation.pdf) `AN041` is helpful.

Key takehome is that it is not known which brightness we get when ordering, but a particular reel has a particular brightness group. Using this code on the reel, one can pick the resistor value.

Lets go for a nice traffic light, easy to remember, and with battery disconnected we see a green LED:

- Power Good: Green, PG pin on battery charger
- Charging: Orange, STAT1 pin on battery charger
- EOC: Red, STAT2 pin on battery charger

Positive voltage at the 'round' pin, negative voltage at the flat side.

#### Red
VBus is from USB, so 5V, the pin sinks.

- Color: `super red`:
- `KS EELP41.22-P1R2-58-A8J8-020-R18`
- https://www.digikey.ca/en/products/detail/ams-osram-usa-inc/KS-EELP41-22-P1R2-58-A8J8-020-R18/24765247

Brightness groups:
- P1 is brightness group 45-56 mcd at 20mA. (~50)
- 4 more groups here.
- R2 brightness group 140-180 mcd at 20mA. (~150)

Average of all groups is ~100 mcd at 20mA.

Forward voltage groups:
- 1.6V - 2.0V
- 2.0V - 2.4V
Nominal is 2V.

Relative luminous intensity is a straight line. Lets say aim is 10mcd?

- P1 brightness group needs 10/50 * 20mA = 4mA, so $R=\frac{V_s - V_f}{I_f}$, `(5-2)/4e-3` = 750 ohm.
- Avg needs 10/100 * 20mA = 2mA, so $R=\frac{V_s - V_f}{I_f}$, `(5-2)/2e-3` = 1500 ohm.
- R2 brightness group needs 10/150 * 20mA = 1.3mA, so $R=\frac{V_s - V_f}{I_f}$, `(5-2)/1.3e-3` = 2250 ohm.

Note; 3.3k ohm seems to be more than bright enough. 6.8k also works. 10k is dim, but still easily visisble, makes the 'dot' visible. Lets go with 4.3k

#### Orange
, VBus is from USB, so 5V, the pin sinks.

- Color: `orange`:
- `KO EELP41.22-Q1S2-25-A8J8-020-R18`
- https://www.digikey.ca/en/products/detail/ams-osram-usa-inc/KO-EELP41-22-Q1S2-25-A8J8-020-R18/24765237

Brightness groups:
- Q1 is brightness group 71-90 mcd at 20mA. (~80)
- 4 more groups here.
- S2 brightness group 224-280 mcd at 20mA. (~252)

Average of all groups is ~166 mcd at 20mA.

Forward voltage groups:
- 1.6V - 2.0V
- 2.0V - 2.4V
Nominal is 2V.

Relative luminous intensity is a straight line. Lets say aim is 10mcd?

- Q1 brightness group needs 10/80 * 20mA = 2.5mA, so $R=\frac{V_s - V_f}{I_f}$, `(5-2)/2.5e-3` = 1200 ohm.
- Avg needs 10/166 * 20mA = 1.2mA, so $R=\frac{V_s - V_f}{I_f}$, `(5-2)/1.2e-3` = 2500 ohm.
- S2 brightness group needs 10/252 * 20mA = 0.8mA, so $R=\frac{V_s - V_f}{I_f}$, `(5-2)/0.8e-3` = 3750 ohm.

Parts:
A1: RaspberryPi_Pico_W; RaspberryPi_Pico_2w_tht; DigiKey_Part 2648-SC1633CT-ND
C1, C4, C5, C6, C7, C9, C10, C11: 100 nF; C_0402_1005Metric; DigiKey_Part 1276-1022-1-ND
C2: 2.2uF; C_0402_1005Metric; DigiKey_Part 1276-1461-1-ND
C3: 10nF; C_0402_1005Metric; DigiKey_Part 1276-1028-1-ND
C8: 4.7uF; C_0603_1608Metric; DigiKey_Part 1276-1044-1-ND
CHG1: LED_CHG; LED_0603_1608Metric; DigiKey_Part KO EELP41.22-Q1S2-25-A8J8-020-R18
ICM-42688-P1: ICM-42688-P; LGA-14_3x2.5mm_P0.5mm_tospec; DigiKey_Part 1428-ICM-42688-PCT-ND
IND1: LED_IND; LED_0603_1608Metric; DigiKey_Part KB EELP41.12-P1R2-36-3X4X-5-R18
J1: Micro_SD_Card_Det2; microSD_HC_Molex_104031-0811; DigiKey_Part WM6357CT-ND
J2: JSTHeader; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal_no_silk; DigiKey_Part 455-1719-ND
J3, J4: PinHeader; PinHeader_1x02_P2.54mm_Vertical_round_no_silk_courtyard; not fitted
JP1: Channel; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
LED_EOC1: LED_EOC; LED_0603_1608Metric; DigiKey_Part KS EELP41.22-P1R2-58-A8J8-020-R18
LED_PG1: LED_PG; LED_0603_1608Metric; DigiKey_Part KT EELP41.12-S2U1-25-2X4Y-5-R18
LSM6DSV320X1: LSM6DSV320X1; LGA-14_3x2.5mm_P0.5mm_tospec; DigiKey_Part 497-LSM6DSV320XTRCT-ND
MK1: ICS-43434; InvenSense_ICS-43434-6_3.5x2.65mm; DigiKey_Part 1428-1066-1-ND
Q1: DMG2305UX; SOT-23_diodes_inc_standard; DigiKey_Part DMG2305UX-7DICT-ND
R1, R2: 4.7k; R_0402_1005Metric; DigiKey_Part P4.70KLCT-ND
R3: 2.49k; R_0402_1005Metric; DigiKey_Part P2.49KLCT-ND
R4, R7, R8, R10: 10k; R_0402_1005Metric; DigiKey_Part P10.0KLCT-ND
R5: 4.3k; R_0402_1005Metric; DigiKey_Part P4.32KLCT-ND
R6, R11: 5k; R_0402_1005Metric; DigiKey_Part 10-ERA-2AEB4991XCT-ND
R9: 2.2k; R_0402_1005Metric; DigiKey_Part P2.20KLCT-ND
U2: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering; DigiKey_Part 828-1063-1-ND
U3: MCP73833-AMI-MF; DFN-10-1EP_3x3mm_P0.5mm_EP1.58x2.35mm; DigiKey_Part MCP73833T-AMI/MFCT-ND
U4: MX25L3233FM2; SOIC-8_5.3x5.3mm_P1.27mm; DigiKey_Part 1092-1234-ND

Connections:
3v3: A1.36 (3V3), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.2, C10.1, C11.2, ICM-42688-P1.5 (VDDIO), ICM-42688-P1.8 (VDD), J1.4 (VDD), JP1.3 (B), LSM6DSV320X1.5 (VDDIO), LSM6DSV320X1.8 (VDD), MK1.5 (VDD), R1.1, R2.1, U2.2 (CSB), U2.6 (VDDIO), U2.8 (VDD), U4.7 (~HOLD/SIO3), U4.8 (VCC)
/BME280_I2C0_SCL: A1.27 (I2C0_SCL), R2.2, U2.4 (SCK)
/BME280_I2C0_SDA: A1.26 (I2C0_SDA), R1.2, U2.3 (SDI)
/CHG_CHARGING: R3.2, U3.3 (STAT1)
/CHG_CURRENT: R6.2, R11.2, U3.6 (PROG)
/CHG_EOC: R5.2, U3.4 (STAT2)
/CHG_THERM: R10.2, U3.8 (THERM)
/I2S_CLK: A1.11 (GPIO8), MK1.4 (SCK)
/I2S_DATA: A1.12 (GPIO9), MK1.6 (SD)
/I2S_WS: A1.10 (GPIO7), MK1.1 (WS)
/ICM_INT1: A1.9 (GPIO6), ICM-42688-P1.4 (INT1/INT)
/ICM_INT2: A1.2 (GPIO1), ICM-42688-P1.9 (INT2/FSYNC/CLKIN)
/ICM_RX_SPI0: A1.6 (SPI0_RX), ICM-42688-P1.1 (AP_SDO/AP_ADO)
/ICM_SCK_SPI0: A1.4 (SPI0_SCK), ICM-42688-P1.13 (AP_SCL/AP_SCLK)
/ICM_TX_SPI0: A1.5 (SPI0_TX), ICM-42688-P1.14 (AP_SDA/AP_SDIO/AP_SDI)
/ICM_~SPI0_CSn: A1.7 (~SPI0_CSn), ICM-42688-P1.12 (AP_CS)
/LSM_INT1: A1.19 (GPIO14), LSM6DSV320X1.4 (INT1)
/LSM_INT2: A1.20 (GPIO15), LSM6DSV320X1.9 (INT2)
/LSM_RX_SPI1: A1.16 (SPI1_RX), LSM6DSV320X1.1 (SDO/TA0)
/LSM_SCK_SPI1: A1.14 (SPI1_SCK), LSM6DSV320X1.13 (SCL)
/LSM_TX_SPI1: A1.15 (SPI1_TX), LSM6DSV320X1.14 (SDA)
/LSM_~SPI1_CSn: A1.17 (~SPI1_CSn), LSM6DSV320X1.12 (CS)
/MEM_SPI0_RX: A1.21 (SPI0_RX), J1.7 (DAT0), U4.2 (SO/SIO1)
/MEM_SPI0_SCK: A1.24 (SPI0_SCK), J1.5 (CLK), U4.6 (SCLK)
/MEM_SPI0_TX: A1.25 (SPI0_TX), J1.3 (CMD), U4.5 (SI/SIO0)
/MEM_~SPI0_CSn: A1.22 (~SPI0_CSn), U4.1 (~CS)
/SD_CS: A1.32 (GPIO27_ADC1), J1.2 (DAT3/CD)
/SD_DET: A1.29 (GPIO22), J1.10 (DET_A)
/SWCLK: A1.D1 (SWCLK)
/SWDIO: A1.D3 (SWDIO)
/VBat: C8.1, J2.1, J3.1, Q1.3 (D), R7.1, U3.9 (V_{BAT}), U3.10 (V_{BAT})
/~PG: R4.2, U3.7 (~PG)
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.33 (AGND), A1.38 (GND), A1.D2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.1, ICM-42688-P1.2 (RESV), ICM-42688-P1.3 (RESV), ICM-42688-P1.6 (GND), ICM-42688-P1.7 (RESV), IND1.1 (K), J1.6 (VSS), J1.9 (DET_B), J1.11 (SHIELD), J2.2, J3.2, J4.1, JP1.1 (A), LSM6DSV320X1.6 (GND), LSM6DSV320X1.7 (GND), MK1.3 (GND), R6.1, R8.2, R10.1, R11.1, U2.1 (GND), U2.5 (SDO), U2.7 (GND), U3.5 (V_{SS}), U3.11 (EP), U4.4 (GND)
unnamed: A1.1 (GPIO0), J4.2
unnamed: A1.31 (GPIO26_ADC0), R9.1
unnamed: CHG1.1 (K), R3.1
unnamed: IND1.2 (A), R9.2
unnamed: JP1.2 (C), MK1.2 (LR)
unnamed: LED_EOC1.1 (K), R5.1
unnamed: LED_PG1.1 (K), R4.1
VBAT_DIV: A1.34 (GPIO28_ADC2), R7.2, R8.1
VBUS: A1.40 (VBUS), CHG1.2 (A), LED_EOC1.2 (A), LED_PG1.2 (A), Q1.1 (G), U3.1 (V_{DD}), U3.2 (V_{DD})
VSYS: A1.39 (VSYS), Q1.2 (S)

Notes on the sheet:
charge_compl
One resistor can be cut off for 5k Ohm total instead of 2.5k. That drops from 400mA charge to 200mA.
BME280 in i2c config
Typically, single cell LiPo batteries are terminated with a two pin JST-PH female connector. These are polarized connectors with pin 1 as +VBATT (red wire) and pin 2 connected to ground (black wire). These mate with the two pin JST-PH male connector (shroud). https://learn.sparkfun.com/tutorials/si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
nop
charge_prog
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
Board: 2 copper layers, 21.0 x 51.0 mm, 39 parts (2 on the bottom side), 41 nets.

## Commit log (part)

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2025-07-14 Cleanup, enums for reboot.
2025-07-15 Improve handling and buffers in defmt serial.
2025-07-15 Note about firmware in partitions.
2025-07-16 This panic handler counts up.
2025-07-17 This does something.
2025-07-17 Put the panic storage in the watchdog scratch instead.
2025-07-17 Add note about USB ids.
2025-07-18 Notes on LED brightness tests.
2025-07-19 Update schematic and pcb with picked resistors.
2025-07-19 Verified WHO_AM_I register of ICM42688.
2025-07-19 Confirmed LSM6dsv320x responds on SPI1.
2025-07-19 Confirmed flash is responsive.
2025-07-19 Test adc.
2025-07-19 Move the Wifi test into hw_test module.
2025-07-20 Can't seem to bitbang this.
2025-07-20 Pull in i2s output pio logic.
2025-07-20 Found the stall, odd side pin order requirements.
2025-07-20 Swap word select & clock in program sides. Since I can't swap the pins.
2025-07-20 Data finally agrees with sigrok decoding.
2025-07-21 Switch the serial port to use an embassy pipe instead of heapless spsc.
2025-07-22 Add function to dump raw bytes into the serial port.
2025-07-23 Work in progress on the partitions.
2025-07-23 Not yet reading fw from the new partitions.
2025-07-23 Some more notes on the firmware.
2025-07-24 First register settings.
2025-07-24 Getting raw readouts from the bme280.
2025-07-24 Refactor such that we can do cargo t --target x86_64-unknown-linux-gnu
2025-07-25 Actually able to run a unit tests.
2025-07-25 Compensation on device.
2025-07-25 Reasonable pressure calculation, still needs verification.
2025-07-25 Add humidity compensation.
2025-07-25 Some documentation, comment out measurements.
2025-07-25 Drop RISC-V linker script and instructions.
2025-07-26 Second board assembled & tested.
2025-07-26 Make unit tests pass by ignoring the example.
2025-07-26 Static files module for serializing files with their data.
2025-07-27 Overhaul static file flashing and readme.
2025-07-27 Start of obtaining partition data.
2025-07-27 Load fw from the static files partition.
2025-07-27 Shared SPI bus, scaffolding.
2025-07-28 Temperature and high G readout.
2025-07-28 Fill the fifo.
2025-07-28 First reads from the fifo.
2025-07-29 Comments and reduce data rate.
2025-07-30 Bump versions forward.
2025-07-30 Proper setting register for the batch data rate.
2025-08-01 Data appears to be coming in as big endian.
2025-08-01 Handle fifo configuration, data rates and reading.
2025-08-02 Notes from reading a bit of the matter spec.
2025-08-04 Start using workspace, scaffolding for trouble_hap.
2025-08-06 Start of the homekit uuid.
2025-08-06 Start of the uuids for the actual service.
2025-08-07 Add the second service.
2025-08-08 This doesn't work easily, because of type erasure.
    The Characteristic<> we can get from the gatt server like this is type erased and only provides AsGatt, not our new method.
2025-08-09 This direction is also going nowhere, because the types are in Characteristic.
2025-08-09 Lets try this approach for now.
2025-08-09 Roll out logging.
2025-08-09 Helper to set the accessory information.
2025-08-09 The UUID was the incorrect order.
2025-08-09 Pairing doesn't quit, but now seems to go 'this may take a few minutes'.
2025-08-09 Confirmed the services.
2025-08-10 It is trying to write to the service signature.
2025-08-10 Start of some struct handling.
2025-08-10 Refactor, switch heapless version.
2025-08-10 Start of pdu handling, how do we deal with the dynamically sized payloads?
2025-08-11 Start of PDU helpers, response to the write request.
    Device disconnects :<
2025-08-11 This is followed by a read on the same attr.
2025-08-12 Print errors, got a new packet to handle.
2025-08-12 More concrete types, header parsing.
    Todo on the next step.
2025-08-13 Mock up of how to make the table manually.
2025-08-14 Refactor, provide shadow tree.
2025-08-14 Need a presentation format here.
2025-08-14 Add properties, hook up the method.
2025-08-15 Fix first mistakes in response, but it's still rejected.
2025-08-16 Switch MTU before starting attribute server.
2025-08-16 Remove descriptors on service instances.
2025-08-16 Change all ids to match the reference as best as possible.
2025-08-16 Getting hits on pair setup now.
2025-08-16 Now on pair verify not being accepted.
2025-08-16 Svc properties on protocol.service signature are wrong.
2025-08-17 We got a write to the pair setup characteristic!
2025-08-17 Start of handling the pair setup write request.
2025-08-17 TVL reader.
2025-08-17 Reader return reponse flag.
2025-08-17 Explore typed TLV wrapper.
2025-08-17 Macro to generate typed TLVs.
2025-08-17 Add and handle pairing flags.
2025-08-18 Start on no_std srp.
2025-08-18 Use lazy static for precalculating the k.
2025-08-19 Correct loading of different sizes.
2025-08-19 Exponentiation over the correct generator.
2025-08-19 Fix unit tests and create the ServerPairSetup struct.
2025-08-20 Actually calculate ephemeral B.
2025-08-21 Start of TLV writer.
2025-08-21 Add buffer overrun handling in the writer.
2025-08-21 Start of hooking up the pairing functionality.
2025-08-22 Start hooking up the pairing to the bluetooth endpoint.
2025-08-22 Use new recording with private values.
2025-08-22 Need a PDU reassembler now.
2025-08-22 Use the correct PDU reassembled value in the test, now need a TLV reassembler.
2025-08-22 TLV Coalescing iterator.
2025-08-23 Annotating constants, srp diverges from the spec.
2025-08-23 Calculate the shared secrets.
2025-08-23 Shared secret calculation.
2025-08-23 Calculate session key outside of srp server object.
2025-08-23 Calculate m2.
2025-08-23 Start of session, notes on session counts.
2025-08-23 Fix warnings.
2025-08-23 Could be receiving encrypted data now.
2025-08-24 Use in-place decryption.
2025-08-24 Refactor files into crypto module.
2025-08-24 Refactor bluetooth module to facilitate testing.
2025-08-24 Decrypt using local buffer.
2025-08-24 Add encrypting the reply, still disconnected.
2025-08-24 Correct characteristic signature response.
2025-08-24 Change pairing feature support results in question about uncertified accessory.
2025-08-24 Decrypting the encrypted data.
2025-08-24 Verify the public key and signature.
2025-08-25 Clean up spamming warnings.
2025-08-26 Add creation of public key, signing.
2025-08-26 Progress on the M6 stage.
2025-08-26 Finished m6.
2025-08-27 Scaffolding for pair_verify.
2025-08-28 Map the HAP x25519 functions to the x25519_dalek primitives.
2025-08-28 Start of message response.
2025-08-28 Start of processing m3.
2025-08-30 Process M3.
2025-08-30 Add pair verify session.
2025-08-30 Add hardware revision message.
2025-08-30 Add more session characteristic requests, problem on identify.
2025-08-30 Have to handle the lightbulb service now.
2025-08-30 Trim dependencies, only crypto-common now uses std.
2025-08-30 Make it compile for arm.
2025-08-30 Exploration on type erasure.
2025-08-30 Overhaul attribute.
2025-08-30 Can read the lightbulb name.
2025-08-30 Protocol configuration and broadcast key next.
2025-08-31 Remove unused GattString.
2025-08-31 Make protocol configuration procedure report correctly.
2025-08-31 Add more messages, now on characteristic configuration.
2025-08-31 First value reads on the lightbulb.
2025-08-31 Need to handle pair verify now.
2025-09-01 Handle pair verify resume.
2025-09-01 We are toggling the bulb, without broadcasts.
2025-09-01 main_ble encounters InvalidValue error from pair verify M3.
2025-09-01 Add debug, why doesn't the lightbulb service appear?
2025-09-01 Order of services in the server matters!?
2025-09-02 Don't print the hap context.
2025-09-02 Bump bt-hci, trouble to after the PR for the last handle fix.
2025-09-02 Clean up warnings.
2025-09-04 Start of HAP on firmware, different bt-hci now.
2025-09-04 Bump embassy time in trouble fixes the issues, error in processing now.
2025-09-06 Make prints defmt compatible.
2025-09-06 Change printing, make defmt and log compile, resolve dependencies.
2025-09-06 add some prints, allocate context on heap, still getting disconnect.
2025-09-06 SRP benchmark setup.
2025-09-06 Limit number of bits in calculation of SRP public ephemeral.
2025-09-06 Hook up LED to bulb. We can toggle the LED from Home!
2025-09-07 Split out micro_hap.
2025-12-07 Use the latest micro_hap version.
2025-12-07 Add humidity sensor.
2025-12-07 Also notify on the humidity change.
2026-02-03 Scaffolding for the flash object.
2026-02-03 Toggling 4 byte address mode.
2026-02-03 Implement software reset.
2026-02-03 Note for myself about disabling the hap entry.
2026-02-04 First write.
2026-02-05 Start of unit test for chunker.
2026-02-06 First aligned chunker.
2026-02-06 Add erase chunker.
2026-02-06 Introduce abstraction trait for flash.
2026-02-07 Blind implementation of find most recent record.
2026-02-07 Drop const from the iterators.
2026-02-07 First mock write with record manager.
2026-02-07 Bugfix, reinitialise.
2026-02-07 Wrapping write.
2026-02-07 Add marker u8.
2026-02-08 First full wrapping cycle.
2026-02-08 Add start of fuzz-like-test.
2026-02-08 Fix bug in dirty record handling.
2026-02-08 It actually passess.
2026-02-08 Clear front & write front needs to happen in one session.
2026-02-08 Fuzzer currently breaks if write stops mid-counter.
2026-02-08 Overhauled parser.
2026-02-08 Remedy situation with next free unclear.
2026-02-08 Looks like it's finally passing all tests & fuzz.
2026-02-08 Update documentation.
2026-02-10 Make the arm build work again.
2026-02-10 Further cleanup in init.
2026-02-10 Remove end erase done.
2026-02-10 Vary the start position.
2026-02-11 Add some helper methods.
2026-02-12 Erasing is failing??
2026-02-12 Remove redundant test.
2026-02-12 Disable tests, measure verifier computation.
2026-02-13 Make a helper to create a seeded ChaCha rng.
2026-02-14 Start of bootrecord counting.
2026-02-14 Code to detect need for factory reset.
2026-02-14 Add read with offset functions.
2026-02-14 Bump micro_hap.
2026-02-14 Wip, untested read/write for pairings.
2026-02-17 Add documentation to mx25.
2026-02-17 Polish docs in flash memory.
2026-02-19 Some more low hanging clippy warnings.
2026-02-21 Split rp2350 support tooling into separate crate.
2026-02-21 Remove imu IC logic from the main / hap firmware dir.
2026-02-21 Give picotool reset interface a string.
2026-02-21 Allow more endpoints, reset & two cdc's working now.
2026-02-21 Add test functions back.
2026-02-21 LSM produces 159 kb/s.
2026-02-22 Status register support; fifo is overflowing from ICM.
2026-02-22 Use concrete types.
2026-02-22 Move it into tasks, but enabling LSM still hurts output rate.
2026-02-23 Add data type entry.
2026-02-24 Notes on fifo contents.
2026-02-24 Scaffolding for analysis package.
2026-02-24 Reading data from the serial port.
2026-02-25 Some brainstorming notes on parsing the stream.
2026-02-26 No joy on parsing data tags, do we have bit errors on the SPI?
2026-02-26 Write splitter test, use section guaranteed from start of sequence.
2026-02-26 Fix order of data tag fields.
2026-02-26 Add timestamps.
2026-02-27 Parsing the first fifo fields into values.
2026-02-27 Add temperature handling.
2026-02-27 FIrmware side is overrunning and causing malformed data?
2026-02-28 First writes to embedded function register to enable sflp.
2026-02-28 Game rotation vector spans two FIFO words.
2026-02-28 Add functionality for game quaternion.
2026-02-28 Add data rate for game entry.
2026-02-28 Disable game output.
2026-03-01 Add fifo header parsing.
2026-03-01 Parse ICM fifo header.
2026-03-02 First output of icm headers.
2026-03-02 Push data aligned on FIFO boundary.
2026-03-03 Toggle 20 bit flag.
2026-03-04 Parser for the ICM fifo object.
2026-03-04 First floats, but scaling is way off.
2026-03-04 Add scaling for gyroscope.
2026-03-05 Add a time tracker to handle the icm timestamp rollover.
2026-03-05 Add scaling to float to the lsm types.
2026-03-06 Bump everything back to 8k.
2026-03-06 Add optinal rerun dependency with fix for ssmarshal.
2026-03-06 Add ICM stream.
2026-03-06 Correct scaling.
2026-03-07 Give the two imu's a common time anchor.
2026-03-07 Drop buffers at start.
2026-03-07 Drop default features for embassy-usb, to avoid ssmarshal dep.
2026-03-07 ICM clock skew correction.
2026-03-07 Dump clock skews to rerun.
2026-03-08 Change high G scale to ensure hitting the table doesn't saturate.
2026-03-09 Add dt output, change to 2khz.
